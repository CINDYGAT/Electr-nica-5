# Keil uVision project nuevas pruebas.uvprojx, settings and files
target Target_1 (6220000::V6.22::..\..\..\..\..\..\Program Files (x86)\ArmCompilerforEmbedded6.22)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nuevas pruebas
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry=Start
  group Source Group 1
    ./: Startup.s PF1codigo.s
